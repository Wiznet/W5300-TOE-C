# Keil uVision project NUCLEO-F439ZI.uvprojx, settings and files
target NUCLEO-F439ZI (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F439ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: NUCLEO-F439ZI +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F439xx,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../../Libraries/ioLibrary_Driver/Ethernet;../../../Libraries/ioLibrary_Driver/Ethernet/W5300;../../../Libraries/ioLibrary_Driver/Internet/DHCP;../../../Libraries/ioLibrary_Driver/Internet/DNS;../../../Libraries/ioLibrary_Driver/Internet/httpServer;../../../Libraries/ioLibrary_Driver/Internet/MQTT;../../../Libraries/ioLibrary_Driver/Internet/MQTT/MQTTPacket/src;../../../Libraries/ioLibrary_Driver/Internet/SNTP;../../../Libraries/ioLibrary_Driver/Application/loopback;../../../Libraries/mbedtls/include;../../../Libraries/mbedtls/library;../../../Port;../../../Port/ioLibrary_Driver/inc;../../../Port/mbedtls/inc;../../../Port/timer/inc;../../../Examples;../../../Examples/http;../../../Examples/http/server;../../../Examples/mqtt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f439xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Libraries/ioLibrary_Driver
    ../../../Libraries/ioLibrary_Driver/Ethernet/W5300/: w5300.c
    ../../../Libraries/ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ../../../Libraries/ioLibrary_Driver/Internet/DHCP/: dhcp.c
    ../../../Libraries/ioLibrary_Driver/Internet/DNS/: dns.c
    ../../../Libraries/ioLibrary_Driver/Internet/httpServer/: httpParser.c httpServer.c httpUtil.c
    ../../../Libraries/ioLibrary_Driver/Internet/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../../../Libraries/ioLibrary_Driver/Internet/MQTT/: mqtt_interface.c MQTTClient.c
    ../../../Libraries/ioLibrary_Driver/Internet/SNTP/: sntp.c
    ../../../Libraries/ioLibrary_Driver/Application/loopback/: loopback.c
  group Libraries/mbedtls
    ../../../Libraries/mbedtls/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c
  group Port/ioLibrary_Driver
    ../../../Port/ioLibrary_Driver/src/: w5x00_bus.c w5x00_network.c
  group Port/timer
    ../../../Port/timer/src/: w5x00_timer.c
  group Examples/dhcp
    ../../../Examples/dhcp/: w5x00_dhcp.c
  group Examples/dns
    ../../../Examples/dns/: w5x00_dns.c
  group Examples/http
    ../../../Examples/http/server/: w5x00_http_server.c
  group Examples/mqtt
    ../../../Examples/mqtt/publish/: w5x00_mqtt_publish.c
    ../../../Examples/mqtt/subscribe/: w5x00_mqtt_subscribe.c
    ../../../Examples/mqtt/publish_subscribe/: w5x00_mqtt_publish_subscribe.c
  group Examples/sntp
    ../../../Examples/sntp/: w5x00_sntp.c
  group Example/tcp_client_over_ssl
    ../../../Examples/tcp_client_over_ssl/: w5x00_tcp_client_over_ssl.c
  group Examples/loopback
    ../../../Examples/loopback/: w5x00_loopback.c
software components: CMSIS:CORE 4.3.0
